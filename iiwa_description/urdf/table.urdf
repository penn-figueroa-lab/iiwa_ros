Commit message: Added tool to apply acceleration control

File: iiwa_description/urdf/table.urdf (robot description, URDF)
Before this commit: robot table, 2 links, 1 joints
Joints:
- joint fixed_to_world: origin xyz=0.9 0 0.3 -> xyz=0.7 0 0.2
